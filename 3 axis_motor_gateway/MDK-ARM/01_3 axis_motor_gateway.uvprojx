# Keil uVision project 01_3 axis_motor_gateway.uvprojx, settings and files
target 01_3 axis_motor_gateway (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 01_3 axis_motor_gateway +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./source;./source/App;./source/Int;./source/Com;./FreeRTOS;./FreeRTOS/include;./source/Int/CAN;./source/Int/MQTT;.\thirdpart\W5500;.\thirdpart\MQTT;.\thirdpart\MQTT\MQTTPacket\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group thirdpart/FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
    ./FreeRTOS/portable/: heap_4.c port.c
  group App
    ./source/App/: App_Main.c
  group Com
    ./source/Com/: cJSON.c
  group Int
    ./source/Int/CAN/: Int_CAN.c
    ./source/Int/MQTT/: Int_MQTT.c
    ./thirdpart/W5500/: Int_W5500.c wizchip_conf.c
  group thirdpart/W5500
    ./thirdpart/W5500/: dhcp.c dhcp.h dns.c dns.h httpParser.c httpParser.h httpServer.c httpServer.h httpUtil.c httpUtil.h socket.c socket.h w5500.c w5500.h
    ./thirdpart/MQTT/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h
    ./thirdpart/MQTT/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
software components: CMSIS:CORE 4.3.0
